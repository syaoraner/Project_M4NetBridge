# IAR project M4_Netbridge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT
  ICCARM.CCIncludePath2: ; .; ..; ..\utils; ..\third_party\lwip-1.4.1\apps; ..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\third_party\lwip-1.4.1\src\include; ..\third_party\lwip-1.4.1\src\include\ipv4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: M4_Netbridge.bin
  ILINK.IlinkOutputFile: PLC-NetBri.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    ../driverlib/ewarm/Exe/: driverlib.a
  group src
    src/: CmdProc.c httpweb.c main.c Relink.c startup_ewarm.c SysInit.c TCPProc.c UARTFun.c UDPFun.c watchDogFun.c
    ../utils/: locator.c lwiplib.c ustdlib.c
    ../Project_M4NetBridge_FreeRTOS/src/: save.c
